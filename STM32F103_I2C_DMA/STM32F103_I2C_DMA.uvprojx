# Keil uVision project STM32F103_I2C_DMA.uvprojx, settings and files
target STM32F103_I2C_DMA (6160000::V6.16::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_I2C_DMA
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\STM32F103_I2C_DMA;.\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group app
    ./app/: app.c
  group inc
    ./inc/: app.h init_LED.h delay.h init_I2C.h
  group init
    ./init/: init_LED.c delay.c init_I2C.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
