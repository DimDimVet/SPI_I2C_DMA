# Keil uVision project STM32F407_SPI_DMA_Rx.uvprojx, settings and files
target STM32F407_SPI_DMA_Rx (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_SPI_DMA_Rx
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\STM32F407_SPI_DMA_Rx;.\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: app.c
  group inc
    ./inc/: app.h delay.h init_SPI.h
  group init
    ./init/: init_SPI.c
  group lib
    ./lib/: delay.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
