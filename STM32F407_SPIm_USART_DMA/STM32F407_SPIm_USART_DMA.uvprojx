# Keil uVision project STM32F407_SPIm_USART_DMA.uvprojx, settings and files
target STM32F407_SPIm_USART_DMA (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_SPIm_USART_DMA
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\STM32F407_SPIm_USART_DMA;.\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: app.c
  group inc
    ./inc/: app.h init_LED.h delay.h init_SPI.h init_USART.h
  group init
    ./init/: init_LED.c delay.c init_SPI.c init_USART.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
