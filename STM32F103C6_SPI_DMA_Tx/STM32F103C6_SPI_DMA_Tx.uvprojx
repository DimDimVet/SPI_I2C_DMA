# Keil uVision project STM32F103C6_SPI_DMA_Tx.uvprojx, settings and files
target STM32F103C6_SPI_DMA_Tx (6190000::V6.19::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C6_SPI_DMA_Tx
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\STM32F103C6_SPI_DMA_Tx;.\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group app
    ./app/: app.c
  group inc
    ./inc/: app.h delay.h init_SPI.h
  group init
    ./init/: init_SPI.c
  group lib
    ./lib/: delay.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
